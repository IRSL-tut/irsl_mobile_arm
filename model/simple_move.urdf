Commit message: add files for base and arm

File: model/simple_move.urdf (robot description, URDF)
Before this commit: robot Simple, 3 links, 2 joints
Links:
- link main: mass 1.0 -> 2.5; geometry collision cylinder length=0.1 radius=0.2; visual cylinder length=0.01 radius=0.02
